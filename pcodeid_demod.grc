options:
  parameters:
    author: allison
    generate_options: qt_gui
    id: PcodeID_Demodulator
    output_language: python
    title: PcodeID Demodulator
  states: {}

blocks:
- name: bw
  id: variable
  parameters:
    value: 2 / txpl
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '4'
  states: {}
- name: pulselen
  id: variable
  parameters:
    value: '500e-6'
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    label: RF gain
    start: '0'
    step: '1'
    stop: '76'
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.048e6
  states: {}
- name: tuning
  id: variable_qtgui_range
  parameters:
    label: frequency
    start: 1e6
    step: 20e3
    stop: 30e6
    value: 10.5e6
  states: {}
- name: txpl
  id: variable
  parameters:
    value: '500e-6'
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/user/Documents/gnuradio/hamsci/iqdata.bin
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {state: disabled}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Phase-Coded Pulse Decoder with Correlation Matching"""

          def __init__(self, threshold=0.001, pulselen=500e-6, bits=5, samp_rate=5e6):
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Correlation Based Phase Code Decoder',
                  in_sig=[np.float32],  # bipolar baseband input
                  out_sig=[np.float32]
              )
              
              # Parameters
              self.threshold = threshold
              self.pulselen = pulselen
              self.bits = bits
              self.samp_rate = samp_rate
              
              # Timing calculations
              self.spp = int(self.samp_rate * self.pulselen)  # samples per pulse
              self.spb = self.spp // self.bits  # samples per bit
              self.dip_below_threshold = int(100e-6 * self.samp_rate)
              
              # State machine
              self.in_pulse = False
              self.pulse_num = 0
              self.last_decoded_bit = -1
              self.samps_below_threshold = 0
              
              # Ring buffer for delayed output
              self.output_buffer = np.zeros(self.spb, dtype=np.float32)
              
              # Pulse collection for correlation
              self.current_pulse_bits = []  # Store decoded bits for current pulse
              
              # Reference sequences (data bits only, no pilot)
              # All 16 possible 4-bit sequences for testing
              self.reference_sequences = {
                  'SEQ_0000': np.array([0, 0, 0, 0]),
                  'SEQ_0001': np.array([0, 0, 0, 1]),
                  'SEQ_0010': np.array([0, 0, 1, 0]),
                  'SEQ_0011': np.array([0, 0, 1, 1]),
                  'SEQ_0100': np.array([0, 1, 0, 0]),
                  'SEQ_0101': np.array([0, 1, 0, 1]),
                  'SEQ_0110': np.array([0, 1, 1, 0]),
                  'SEQ_0111': np.array([0, 1, 1, 1]),  # ICE
                  'SEQ_1000': np.array([1, 0, 0, 0]),
                  'SEQ_1001': np.array([1, 0, 0, 1]),
                  'SEQ_1010': np.array([1, 0, 1, 0]),
                  'SEQ_1011': np.array([1, 0, 1, 1]),
                  'SEQ_1100': np.array([1, 1, 0, 0]),  # ICW
                  'SEQ_1101': np.array([1, 1, 0, 1]),  # BKS
                  'SEQ_1110': np.array([1, 1, 1, 0]),
                  'SEQ_1111': np.array([1, 1, 1, 1])
              }
              
              # Correlation threshold (0.0 to 1.0, tune based on SNR)
              self.correlation_threshold = 0.7
              
              # Statistics
              self.matched_pulses = {key: 0 for key in self.reference_sequences.keys()}
              self.unmatched_pulses = 0

          def correlate_pulse(self, pulse_bits):
              """
              Correlate decoded pulse bits against known sequences.
              Returns (best_match_name, correlation_score) or (None, 0) if below threshold.
              """
              if len(pulse_bits) != self.bits - 1:  # Should have bits-1 data bits
                  return None, 0.0
              
              pulse_array = np.array(pulse_bits)
              best_match = None
              best_score = -1.0
              
              for seq_name, ref_seq in self.reference_sequences.items():
                  # Normalize correlation: divide by sequence length
                  correlation = np.sum(pulse_array == ref_seq) / len(ref_seq)
                  
                  if correlation > best_score:
                      best_score = correlation
                      best_match = seq_name
              
              # Check threshold
              if best_score >= self.correlation_threshold:
                  return best_match, best_score
              else:
                  return None, best_score

          def work(self, input_items, output_items):
              """Decode phase-coded pulses with correlation matching"""
              bipolar_in = input_items[0]
              out = output_items[0]
              out[:] = 0  # Default: no pulse
              
              for i in range(len(bipolar_in)):
                  mag = abs(bipolar_in[i])
                  
                  # Pulse detection with hysteresis
                  if not self.in_pulse:
                      if mag > self.threshold:
                          self.in_pulse = True
                          self.pulse_num += 1
                          self.pulse_start_idx = i
                          self.last_decoded_bit = -1
                          self.output_buffer[:] = 0
                          self.current_pulse_bits = []  # Reset pulse collection
                          print(f"\n[PULSE START] Pulse #{self.pulse_num} detected")
                  else:
                      # Check for pulse end
                      samples_in_pulse = i - self.pulse_start_idx
                      
                      if mag < self.threshold:
                          self.samps_below_threshold += 1
                          # Pulse ends after sustained low signal (hysteresis only)
                          if self.samps_below_threshold >= self.dip_below_threshold:
                              # Pulse ended - perform correlation
                              duration_us = (samples_in_pulse / self.samp_rate) * 1e6
                              match_name, match_score = self.correlate_pulse(self.current_pulse_bits)
                              
                              if match_name:
                                  self.matched_pulses[match_name] += 1
                                  print(f"[PULSE END - MATCHED] {match_name} (score: {match_score:.2f}) | "
                                        f"{len(self.current_pulse_bits)} bits | {duration_us:.1f}µs")
                              else:
                                  self.unmatched_pulses += 1
                                  print(f"[PULSE END - UNMATCHED] Best score: {match_score:.2f} | "
                                        f"{len(self.current_pulse_bits)} bits | {duration_us:.1f}µs | "
                                        f"bits={self.current_pulse_bits}")
                              
                              # Print statistics
                              print(f"Stats: {self.matched_pulses} | Unmatched: {self.unmatched_pulses}")
                              
                              self.in_pulse = False
                              self.samps_below_threshold = 0
                              continue
                      else:
                          self.samps_below_threshold = 0
                      
                      # Decode bits during pulse
                      bit_index = samples_in_pulse // self.spb
                      
                      if bit_index < self.bits and bit_index > self.last_decoded_bit:
                          # Calculate stable region for this bit
                          bit_start = bit_index * self.spb
                          stable_start = bit_start + int(0.2 * self.spb)
                          
                          # For last bit, extend stable region to 95% to catch it before pulse ends
                          if bit_index == self.bits - 1:
                              stable_end = bit_start + int(0.95 * self.spb)
                          else:
                              stable_end = bit_start + int(0.8 * self.spb)
                          
                          if stable_start <= samples_in_pulse < stable_end:
                              # Average bipolar signal in stable region
                              local_start = max(0, i - 10)
                              avg_sign = np.sign(np.mean(bipolar_in[local_start:i+1]))
                              
                              if bit_index == 0:
                                  # Pilot bit - store reference
                                  self.pilot_sign = avg_sign
                                  bit_value = 1.0  # Pilot always outputs 1
                                  print(f"Bit 0 (pilot): {bit_value}")
                              else:
                                  # Data bit - compare to pilot (non-differential)
                                  if avg_sign == self.pilot_sign:
                                      bit_value = 1.0  # Same phase as pilot
                                      decoded_bit = 1
                                  else:
                                      bit_value = -1.0  # Opposite phase from pilot
                                      decoded_bit = 0
                                  
                                  self.current_pulse_bits.append(decoded_bit)
                                  print(f"Bit {bit_index} (data): {bit_value} -> {decoded_bit}")
                              
                              self.output_buffer[:] = bit_value
                              self.last_decoded_bit = bit_index
                      
                      # Output from ring buffer
                      out[i] = self.output_buffer[samples_in_pulse % self.spb]
              
              return len(input_items[0])
    bits: '5'
    pulselen: pulselen
    samp_rate: samp_rate / decimation
    threshold: '0.003'
  states: {state: disabled}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 3*bw
    decim: decimation
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 2e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: 10*samp_rate / decimation
    fc: tuning
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    size: '5000'
    srate: samp_rate
    tr_level: '0.01'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
    ymax: '0.02'
    ymin: '-0.02'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0_2
  id: qtgui_time_sink_x
  parameters:
    size: '5000'
    srate: samp_rate / decimation
    tr_level: '0.01'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: complex
    ymax: '0.02'
    ymin: '-0.02'
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: '5000'
    srate: samp_rate / decimation
    tr_level: '0.001'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
  states: {state: disabled}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: 'tuning '
    gain: '0'
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [blocks_complex_to_float_0, '0', epy_block_1, '0']
- [blocks_complex_to_float_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [blocks_complex_to_float_0, '1', blocks_null_sink_0, '0']
- [epy_block_1, '0', qtgui_time_sink_x_1, '0']
- [low_pass_filter_0, '0', blocks_complex_to_float_0, '0']
- [low_pass_filter_0, '0', blocks_file_sink_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [low_pass_filter_0, '0', qtgui_time_sink_x_0_0_0_2, '0']
- [soapy_rtlsdr_source_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
